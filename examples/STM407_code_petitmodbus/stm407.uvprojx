# Keil uVision project stm407.uvprojx, settings and files
target Target 1 (5060183::V5.06 update 2 (build 183)::ARMCC)
  device: STM32F407VGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.14.0
  cpu: IRAM(0x20000000,0x20000) IRAM2(0x10000000,0x10000) IROM(0x08000000,0x100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: stm407
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER
  c include: ..\;.\CMSIS\ST\STM32F4xx;.\CMSIS\ST\STM32F4xx\Source\Templates;.\STM32F4xx_StdPeriph_Driver;.\STM32F4xx_StdPeriph_Driver\inc;.\STM32F4xx_StdPeriph_Driver\src;.\User;.\CMSIS\ST\STM32F4xx\Include;.\CMSIS\ST\STM32F4xx\Source;.\Init;.\Interrupt;.\PetitModbus;.\Headers;.\Functions
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group Startup
    ./: startup_stm32f4xx.s
  group User
    ./: main.c
  group CMSIS
    ./CMSIS/ST/STM32F4xx/Source/Templates/: system_stm32f4xx.c
    ./CMSIS/Include/: core_cm4.h
  group StdPeriph
    ./STM32F4xx_StdPeriph_Driver/src/: misc.c stm32f4xx_gpio.c stm32f4xx_rcc.c stm32f4xx_syscfg.c stm32f4xx_adc.c stm32f4xx_can.c stm32f4xx_crc.c stm32f4xx_cryp.c stm32f4xx_cryp_aes.c stm32f4xx_cryp_des.c stm32f4xx_cryp_tdes.c stm32f4xx_dac.c stm32f4xx_dbgmcu.c stm32f4xx_dcmi.c stm32f4xx_dma.c stm32f4xx_exti.c stm32f4xx_flash.c stm32f4xx_fsmc.c stm32f4xx_hash.c stm32f4xx_hash_md5.c stm32f4xx_hash_sha1.c stm32f4xx_i2c.c stm32f4xx_iwdg.c stm32f4xx_pwr.c stm32f4xx_rng.c stm32f4xx_rtc.c stm32f4xx_sdio.c stm32f4xx_spi.c stm32f4xx_tim.c stm32f4xx_usart.c stm32f4xx_wwdg.c
  group Init
    ./Init/: Init.c Init.h
  group Interrupt
    ./Interrupt/: stm32f4xx_it.c stm32f4xx_it.h
  group PetitModbus
    ./PetitModbus/: PetitModbus.c PetitModbus.h PetitModbusPort.c PetitModbusPort.h PetitRegConstant.c
  group Headers
    ./Headers/: General.c General.h
  group Functions
    ./Functions/: Functions.c Functions.h

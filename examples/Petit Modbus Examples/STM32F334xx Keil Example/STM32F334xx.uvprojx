# Keil uVision project STM32F334xx.uvprojx, settings and files
target STM32F334C8 (5060061::V5.06 update 1 (build 61)::ARMCC)
  device: STM32F334C8 STMicroelectronics
  pack: Keil.STM32F3xx_DFP.1.3.0
  cpu: IROM(0x08000000,0x00008000) IRAM(0x20000000,0x00030000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: STM32F334xx
  c flags: Optim=4 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER,STM32F334x8
  c misc: --C99
  c include: .\Libraries\CMSIS\Include;.\Libraries\CMSIS\Device\ST\STM32F30x\Include;.\Libraries\STM32F30x_StdPeriph_Driver\inc;.\Init;.\General;.\CoOS\kernel;.\CoOS\portable;.\CoOS\portable\Keil;.\CoOS;.\PetitModbus
  memory RVCT4: ROM 0x8000000 size 0x8000
  memory RVCT9: RAM 0x20000000 size 0x30000
  group Source
    ./Source/: main.c
  group STM32F30x_StdPeriph_Driver
    ./Libraries/STM32F30x_StdPeriph_Driver/src/: stm32f30x_adc.c stm32f30x_can.c stm32f30x_dac.c stm32f30x_dbgmcu.c stm32f30x_dma.c stm32f30x_exti.c stm32f30x_flash.c stm32f30x_fmc.c stm32f30x_gpio.c stm32f30x_hrtim.c stm32f30x_i2c.c stm32f30x_iwdg.c stm32f30x_misc.c stm32f30x_opamp.c stm32f30x_pwr.c stm32f30x_rcc.c stm32f30x_rtc.c stm32f30x_spi.c stm32f30x_syscfg.c stm32f30x_tim.c stm32f30x_usart.c stm32f30x_wwdg.c
  group Startup
    ./Startup/: system_stm32f30x.c startup_stm32f334x8.s
  group Interrupts
    ./Interrupts/: stm32f30x_it.c stm32f30x_it.h
  group Init
    ./Init/: Init.c
  group General
    ./General/: General.c
  group CoOS
    ./CoOS/: OsConfig.h
    ./CoOS/kernel/: core.c event.c flag.c hook.c kernelHeap.c mbox.c mm.c mutex.c queue.c sem.c serviceReq.c task.c time.c timer.c utility.c
    ./CoOS/portable/: arch.c
    ./CoOS/portable/Keil/: port.c
  group PetitModbus
    ./PetitModbus/: PetitModbus.c PetitModbusPort.c PetitRegConstant.c
software components: CMSIS:CORE 4.3.0
